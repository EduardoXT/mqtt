## main/Kconfig.projbuild
```kconfig
menu "WIFI CONNECT"

config WIFI_SSID
    string "SSID"
    default "InsoleON"

config WIFI_PASSWORD
    string "PASSWORD"
    default "12345678"  

endmenu
```
